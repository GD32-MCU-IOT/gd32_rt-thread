# Keil uVision project project.uvprojx, settings and files
target rtthread (6160000::V6.16::ARMCLANG)
  device: GD32L233RC GigaDevice
  pack: GigaDevice.GD32L23x_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0008000) IROM(0x08000000,0x0040000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __RTTHREAD__, USE_STDPERIPH_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, GD32L233
  c include: ..\..\..\..\components\finsh;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\components\drivers\smp_call;applications;..\..\..\..\components\net\utest;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;.;..\..\..\..\components\dfs\dfs_v1\include;..\libraries\gd32_drivers;..\..\..\..\components\libc\compilers\common\include;..\..\..\..\components\libc\posix\ipc;..\..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\phy;..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\posix\io\poll;..\..\..\..\include;..\..\..\..\libcpu\arm\common;..\..\..\..\components\drivers\spi\sfud\inc;board;..\..\..\..\components\drivers\include;packages\gd32-arm-series-latest\Include;packages\at24cxx-latest;packages\gd32-arm-cmsis-latest\GD\GD32L23x\Include;..\..\..\..\components\drivers\include;..\..\..\..\libcpu\arm\cortex-m23;..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\components\drivers\spi;..\..\..\..\components\drivers\include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group at24cxx
    packages/at24cxx-latest/: at24cxx.c
  group CPU
    ../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../libcpu/arm/cortex-m23/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
    ../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c dev_spi_flash_sfud.c
    ../../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
  group Drivers
    board/: board.c board_msd_init.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_hard_i2c.c drv_spi.c drv_spi_flash.c drv_usart.c
  group Filesystem
    ../../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../components/finsh/: msh_parse.c msh.c cmd.c msh_file.c shell.c
  group GD32L23x_StdPeriph
    packages/gd32-arm-series-latest/Source/: gd32l23x_cmp.c gd32l23x_wwdgt.c gd32l23x_fmc.c gd32l23x_trng.c gd32l23x_crc.c gd32l23x_ctc.c gd32l23x_timer.c gd32l23x_rcu.c gd32l23x_dbg.c gd32l23x_slcd.c gd32l23x_lptimer.c gd32l23x_fwdgt.c gd32l23x_misc.c gd32l23x_syscfg.c gd32l23x_i2c.c gd32l23x_gpio.c gd32l23x_vref.c gd32l23x_rtc.c gd32l23x_dac.c gd32l23x_lpuart.c gd32l23x_adc.c gd32l23x_pmu.c gd32l23x_spi.c gd32l23x_usart.c gd32l23x_exti.c gd32l23x_dma.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/gd32-arm-cmsis-latest/GD/GD32L23x/Source/ARM/: startup_gd32l233.s
    packages/gd32-arm-cmsis-latest/GD/GD32L23x/Source/: system_gd32l23x.c
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev
