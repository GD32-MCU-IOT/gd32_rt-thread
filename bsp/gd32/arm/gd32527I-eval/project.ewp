# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F527xS GD32F527xS
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: GD32F527; USE_STDPERIPH_DRIVER; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: ..\..\..\..\components\drivers\smp_call; ..\..\..\..\components\libc\posix\io\epoll; ..\..\..\..\libcpu\arm\common; ..\..\..\..\components\drivers\spi; board; packages\gd32-arm-series-latest\GD32F5xx\GD32F5xx_standard_peripheral\Include; ..\..\..\..\components\drivers\phy; packages\at24cxx-latest; ..\..\..\..\libcpu\arm\cortex-m33; applications; ..\..\..\..\components\drivers\include; ..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\components\finsh; .; ..\..\..\..\components\libc\posix\ipc; ..\..\..\..\components\dfs\dfs_v1\include; ..\..\..\..\include; ..\..\..\..\components\libc\posix\io\eventfd; ..\..\..\..\components\libc\posix\io\poll; packages\gd32-arm-cmsis-latest\GD32F5xx\GD\GD32F5xx\Include; ..\..\..\..\components\libc\compilers\common\include; packages\gd32-arm-cmsis-latest\GD32F5xx; ..\..\..\..\components\libc\compilers\common\extension; ..\..\..\..\components\net\utest; ..\..\..\..\components\drivers\sdio\sdhci\include; ..\libraries\gd32_drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; GD32F527; USE_STDPERIPH_DRIVER; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group at24cxx
    packages/at24cxx-latest/: at24cxx.c
  group CPU
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m33/: context_iar.S cpuport.c syscall_iar.S trustzone.c
  group DeviceDrivers
    ../../../../components/drivers/block/: blk.c blk_dev.c blk_dfs.c blk_partition.c
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/sdio/: dev_block.c dev_mmc.c dev_mmcsd_core.c dev_sd.c dev_sdio.c
    ../../../../components/drivers/serial/: dev_serial.c
    ../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
  group Drivers
    board/: board.c board_msd_init.c
    packages/gd32-arm-series-latest/GD32F5xx/GD32F5xx_standard_peripheral/Source/: gd32f5xx_i2c_add.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_hard_i2c.c drv_sdio.c drv_spi.c drv_usart.c
  group Filesystem
    ../../../../components/dfs/dfs_v1/src/: dfs.c dfs_fs.c dfs_posix.c dfs_file.c
  group Finsh
    ../../../../components/finsh/: msh.c msh_parse.c shell.c cmd.c msh_file.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
    ../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/gd32-arm-cmsis-latest/GD32F5xx/GD/GD32F5xx/Source/IAR/: startup_gd32f5xx.s
    packages/gd32-arm-cmsis-latest/GD32F5xx/GD/GD32F5xx/Source/: system_gd32f5xx.c
    packages/gd32-arm-series-latest/GD32F5xx/GD32F5xx_standard_peripheral/Source/: gd32f5xx_dbg.c gd32f5xx_dma.c gd32f5xx_exti.c gd32f5xx_gpio.c gd32f5xx_i2c.c gd32f5xx_misc.c gd32f5xx_rcu.c gd32f5xx_sdio.c gd32f5xx_spi.c gd32f5xx_syscfg.c gd32f5xx_usart.c
