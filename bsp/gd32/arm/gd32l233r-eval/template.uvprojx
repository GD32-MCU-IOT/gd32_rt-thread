# Keil uVision project template.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: GD32L233RC GigaDevice
  pack: GigaDevice.GD32L23x_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0008000) IROM(0x08000000,0x0040000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
software components: CMSIS:CORE 5.5.0
