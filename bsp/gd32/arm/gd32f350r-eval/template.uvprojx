# Keil uVision project template.uvprojx, settings and files
target rt-thread (6160000::V6.16::ARMCLANG)
  device: GD32F350RB GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.3.3.0
  cpu: IRAM(0x20000000,0x04000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\board\linker_scripts\link.sct
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev
