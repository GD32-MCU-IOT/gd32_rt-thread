# Keil uVision project template.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: GD32E517ZE GigaDevice
  pack: GigaDevice.GD32E51x_DFP.1.3.1
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev
