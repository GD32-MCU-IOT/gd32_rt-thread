# Keil uVision project project.uvprojx, settings and files
target rtthread (6160000::V6.16::ARMCLANG)
  device: GD32E235CB GigaDevice
  pack: GigaDevice.GD32E23x_DFP.2.3.2
  cpu: IRAM(0x20000000,0x0004000) IROM(0x08000000,0x0020000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E23X_HD, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, __STDC_LIMIT_MACROS, RT_USING_LIBC, GD32E23X, USE_STDPERIPH_DRIVER, RT_USING_ARMLIBC
  c include: ..\..\..\..\libcpu\arm\cortex-m23;..\..\..\..\components\drivers\smp_call;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\posix\io\poll;..\..\..\..\components\libc\posix\io\eventfd;..\libraries\gd32_drivers;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;packages\at24cxx-latest;..\..\..\..\components\drivers\include;.;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\compilers\common\include;..\..\..\..\include;..\..\..\..\components\net\utest;packages\gd32-arm-cmsis-latest\GD32E23x\GD\GD32E23x\Include;..\..\..\..\components\drivers\phy;..\..\..\..\components\libc\compilers\common\extension;packages\gd32-arm-series-latest\GD32E23x\GD32E23x_standard_peripheral\Include;applications;..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\libcpu\arm\common;..\..\..\..\components\libc\posix\ipc;board;..\..\..\..\components\drivers\include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group at24cxx
    packages/at24cxx-latest/: at24cxx.c
  group CPU
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m23/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c board_msd_init.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_hard_i2c.c drv_usart.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/gd32-arm-cmsis-latest/GD32E23x/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
    packages/gd32-arm-cmsis-latest/GD32E23x/GD/GD32E23x/Source/: system_gd32e23x.c
    packages/gd32-arm-series-latest/GD32E23x/GD32E23x_standard_peripheral/Source/: gd32e23x_dma.c gd32e23x_exti.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_rcu.c gd32e23x_syscfg.c gd32e23x_usart.c
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev
