# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F470xK GD GD32F470xK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: GD32F470; USE_STDPERIPH_DRIVER; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: board; packages\gd32-arm-cmsis-latest\GD32F4xx\GD\GD32F4xx\Include; ..\..\..\..\components\libc\posix\io\epoll; ..\..\..\..\libcpu\arm\cortex-m4; ..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; board\ports; ..\..\..\..\components\drivers\smp_call; ..\libraries\gd32_drivers; ..\..\..\..\components\finsh; ..\..\..\..\components\libc\posix\ipc; ..\..\..\..\components\libc\posix\io\poll; ..\..\..\..\components\libc\posix\io\eventfd; ..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\components\libc\compilers\common\extension; ..\..\..\..\components\net\utest; ..\..\..\..\include; applications; ..\..\..\..\components\dfs\dfs_v1\include; packages\gd32-arm-cmsis-latest\GD32F4xx; ..\..\..\..\components\drivers\phy; .; packages\gd32-arm-series-latest\GD32F4xx\GD32F4xx_standard_peripheral\Include; ..\..\..\..\libcpu\arm\common; ..\..\..\..\components\drivers\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; GD32F470; USE_STDPERIPH_DRIVER; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group CPU
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c board_msd_init.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_usart.c
  group Filesystem
    ../../../../components/dfs/dfs_v1/src/: dfs_posix.c dfs.c dfs_fs.c dfs_file.c
  group Finsh
    ../../../../components/finsh/: shell.c msh_parse.c msh.c msh_file.c cmd.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
    ../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/gd32-arm-cmsis-latest/GD32F4xx/GD/GD32F4xx/Source/IAR/: startup_gd32f4xx.s
    packages/gd32-arm-cmsis-latest/GD32F4xx/GD/GD32F4xx/Source/: system_gd32f4xx.c
    packages/gd32-arm-series-latest/GD32F4xx/GD32F4xx_standard_peripheral/Source/: gd32f4xx_dma.c gd32f4xx_exti.c gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_rcu.c gd32f4xx_syscfg.c gd32f4xx_usart.c
