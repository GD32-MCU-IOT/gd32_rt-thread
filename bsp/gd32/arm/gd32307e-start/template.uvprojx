# Keil uVision project template.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F307VE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.5.0
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(25000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\board\linker_scripts\link.sct
software components: CMSIS:CORE 5.4.0
