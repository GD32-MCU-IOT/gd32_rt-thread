# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F20xxE GD GD32F20xxE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: GD32F20X_CL; USE_STDPERIPH_DRIVER; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: ..\..\..\..\components\libc\posix\io\eventfd; ..\..\..\..\components\drivers\phy; ..\..\..\..\components\finsh; packages\gd32-arm-cmsis-latest\GD32F20x\GD\GD32F20x\Include; packages\gd32-arm-cmsis-latest\GD32F20x; ..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\components\libc\compilers\common\extension; packages\gd32-arm-series-latest\gd32-arm-cmsis-latest\GD32F20x\GD\GD32F20x\Include; ..\..\..\..\libcpu\arm\cortex-m3; ..\..\..\..\components\libc\posix\io\epoll; ..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\components\libc\posix\io\poll; ..\..\..\..\components\drivers\include; ..\..\..\..\components\drivers\smp_call; ..\..\..\..\libcpu\arm\common; ..\..\..\..\include; packages\gd32-arm-series-latest\GD32F20x\GD32F20x_standard_peripheral\Include; packages\gd32-arm-series-latest\gd32-arm-cmsis-latest\GD32F20x; ..\..\..\..\components\net\utest; board; ..\..\..\..\components\libc\posix\ipc; ..\libraries\gd32_drivers; .; applications
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board/linker_scripts/link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; GD32F20X_CL; USE_STDPERIPH_DRIVER; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group CPU
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m3/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c board_msd_init.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_usart.c
  group Finsh
    ../../../../components/finsh/: cmd.c msh_parse.c shell.c msh.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
    ../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/gd32-arm-cmsis-latest/GD32F20x/GD/GD32F20x/Source/IAR/: startup_gd32f20x_cl.s
    packages/gd32-arm-cmsis-latest/GD32F20x/GD/GD32F20x/Source/: system_gd32f20x.c
    packages/gd32-arm-series-latest/GD32F20x/GD32F20x_standard_peripheral/Source/: gd32f20x_adc.c gd32f20x_bkp.c gd32f20x_can.c gd32f20x_cau.c gd32f20x_cau_aes.c gd32f20x_cau_des.c gd32f20x_cau_tdes.c gd32f20x_crc.c gd32f20x_dac.c gd32f20x_dbg.c gd32f20x_dci.c gd32f20x_dma.c gd32f20x_enet.c gd32f20x_exmc.c gd32f20x_exti.c gd32f20x_fmc.c gd32f20x_fwdgt.c gd32f20x_gpio.c gd32f20x_hau.c gd32f20x_hau_sha_md5.c gd32f20x_i2c.c gd32f20x_misc.c gd32f20x_pmu.c gd32f20x_rcu.c gd32f20x_rtc.c gd32f20x_sdio.c gd32f20x_spi.c gd32f20x_timer.c gd32f20x_tli.c gd32f20x_trng.c gd32f20x_usart.c gd32f20x_wwdgt.c
