# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32E113xB GD GD32E113xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: GD32E11X; USE_STDPERIPH_DRIVER; GD32E113; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: .; packages\gd32-arm-cmsis-latest\GD32E11x\GD\GD32E11x\Include; ..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\components\libc\posix\io\eventfd; ..\..\..\..\components\drivers\include; ..\..\..\..\components\drivers\phy; applications; ..\..\..\..\components\drivers\smp_call; ..\..\..\..\include; ..\..\..\..\components\drivers\spi; ..\..\..\..\libcpu\arm\cortex-m4; ..\..\..\..\libcpu\arm\common; ..\..\..\..\components\libc\posix\io\poll; ..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\components\finsh; packages\at24cxx-latest; ..\..\..\..\components\libc\compilers\common\extension; ..\..\..\..\components\libc\posix\io\epoll; ..\..\..\..\components\net\utest; board; ..\..\..\..\components\libc\posix\ipc; ..\libraries\gd32_drivers; packages\gd32-arm-series-latest\GD32E11x\GD32E11x_standard_peripheral\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; GD32E11X; USE_STDPERIPH_DRIVER; GD32E113; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  group Applications
    applications/: main.c
  group at24cxx
    packages/at24cxx-latest/: at24cxx.c
  group CPU
    ../../../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
    ../../../../libcpu/arm/common/: div0.c showmem.c
  group DeviceDrivers
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
    ../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
    ../../../../components/drivers/core/: device.c
  group Drivers
    board/: board.c board_msd_init.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_hard_i2c.c drv_spi.c drv_usart.c
  group Finsh
    ../../../../components/finsh/: cmd.c msh.c msh_parse.c shell.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
    ../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/gd32-arm-series-latest/GD32E11x/GD32E11x_standard_peripheral/Source/: gd32e11x_exti.c gd32e11x_gpio.c gd32e11x_i2c.c gd32e11x_misc.c gd32e11x_pmu.c gd32e11x_rcu.c gd32e11x_spi.c gd32e11x_usart.c
    packages/gd32-arm-cmsis-latest/GD32E11x/GD/GD32E11x/Source/IAR/: startup_gd32e11x.s
    packages/gd32-arm-cmsis-latest/GD32E11x/GD/GD32E11x/Source/: system_gd32e11x.c
