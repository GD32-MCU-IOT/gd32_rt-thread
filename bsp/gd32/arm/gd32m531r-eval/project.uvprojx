# Keil uVision project project.uvprojx, settings and files
target rt-thread (6160000::V6.16::ARMCLANG)
  device: GD32M531RC GigaDevice
  pack: GigaDevice.GD32M53x_DFP.0.3.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x040000) IROM2(0x08800000,0x010000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: GD32M53X, __STDC_LIMIT_MACROS, USE_STDPERIPH_DRIVER, __RTTHREAD__, RT_USING_ARMLIBC, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC
  c misc: -fno-strict-aliasing
  c include: ..\..\..\..\libcpu\arm\cortex-m33;packages\gd32-arm-cmsis-latest\GD32M53x;packages\at24cxx-latest;..\..\..\..\components\libc\compilers\common\include;..\..\..\..\components\libc\posix\io\poll;..\..\..\..\components\libc\posix\ipc;applications;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\smp_call;..\..\..\..\components\drivers\include;.;..\..\..\..\components\dfs\dfs_v1\include;..\..\..\..\components\drivers\include;..\..\..\..\include;..\..\..\..\components\net\utest;..\..\..\..\libcpu\arm\common;..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\components\drivers\spi\sfud\inc;..\..\..\..\components\libc\posix\io\eventfd;packages\gd32-arm-series-latest\GD32M53x\GD32M53x_standard_peripheral\Include;..\..\..\..\components\drivers\include;board;..\..\..\..\components\drivers\spi;packages\gd32-arm-cmsis-latest\GD32M53x\GD\GD32M53x\Include;..\..\..\..\components\drivers\include;..\..\..\..\components\finsh;..\..\..\..\components\drivers\include;..\libraries\gd32_drivers;..\..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\components\drivers\phy
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT5: ROM 0x8800000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group at24cxx
    packages/at24cxx-latest/: at24cxx.c
  group CPU
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
    ../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c dev_spi_flash_sfud.c
    ../../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
  group Drivers
    board/: board.c board_msd_init.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_hard_i2c.c drv_spi.c drv_spi_flash.c drv_usart.c
  group Filesystem
    ../../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../components/finsh/: msh_parse.c cmd.c shell.c msh.c msh_file.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/gd32-arm-cmsis-latest/GD32M53x/GD/GD32M53x/Source/ARM/: startup_gd32m53x.s
    packages/gd32-arm-cmsis-latest/GD32M53x/GD/GD32M53x/Source/: system_gd32m53x.c
    packages/gd32-arm-series-latest/GD32M53x/GD32M53x_standard_peripheral/Source/: gd32m53x_adc.c gd32m53x_can.c gd32m53x_cfmu.c gd32m53x_cmp.c gd32m53x_cptimer.c gd32m53x_cptimerw.c gd32m53x_crc.c gd32m53x_dac.c gd32m53x_dbg.c gd32m53x_dma.c gd32m53x_evic.c gd32m53x_exti.c gd32m53x_fmc.c gd32m53x_fwdgt.c gd32m53x_gpio.c gd32m53x_gptimer.c gd32m53x_gtoc.c gd32m53x_i2c.c gd32m53x_misc.c gd32m53x_pmu.c gd32m53x_poc.c gd32m53x_rcu.c gd32m53x_spi.c gd32m53x_svpwm.c gd32m53x_syscfg.c gd32m53x_timer.c gd32m53x_tmu.c gd32m53x_uart.c gd32m53x_wwdgt.c
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev
