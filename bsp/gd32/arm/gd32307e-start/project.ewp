# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F307xE GD GD32F307xE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: GD32F30X_CL; USE_STDPERIPH_DRIVER; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: ..\..\..\..\components\libc\compilers\common\extension; packages\gd32-arm-cmsis-latest\GD32F30x; ..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\components\libc\posix\io\epoll; ..\..\..\..\components\finsh; ..\..\..\..\components\libc\posix\io\eventfd; packages\gd32-arm-cmsis-latest\GD32F30x\GD\GD32F30x\Include; ..\..\..\..\libcpu\arm\common; ..\..\..\..\include; ..\libraries\gd32_drivers; ..\..\..\..\components\libc\posix\ipc; ..\..\..\..\components\libc\posix\io\poll; packages\gd32-arm-series-latest\GD32F30x\GD32F30x_standard_peripheral\Include; ..\..\..\..\components\drivers\smp_call; .; ..\..\..\..\libcpu\arm\cortex-m4; ..\..\..\..\components\drivers\phy; applications; ..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\components\net\utest; board; ..\..\..\..\components\drivers\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; GD32F30X_CL; USE_STDPERIPH_DRIVER; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group CPU
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
    ../../../../components/drivers/core/: device.c
  group Drivers
    board/: board.c board_msd_init.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_usart.c
    packages/gd32-arm-series-latest/GD32F30x/GD32F30x_standard_peripheral/Source/: gd32f30x_dma.c
  group Finsh
    ../../../../components/finsh/: cmd.c msh.c msh_parse.c shell.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
    ../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/gd32-arm-series-latest/GD32F30x/GD32F30x_standard_peripheral/Source/: gd32f30x_exti.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_rcu.c gd32f30x_usart.c
    packages/gd32-arm-cmsis-latest/GD32F30x/GD/GD32F30x/Source/IAR/: startup_gd32f30x_cl.s
    packages/gd32-arm-cmsis-latest/GD32F30x/GD/GD32F30x/Source/: system_gd32f30x.c
