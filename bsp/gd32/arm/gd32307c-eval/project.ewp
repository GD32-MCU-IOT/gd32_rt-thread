# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F307xC GD GD32F307xC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: GD32F30X_CL; USE_STDPERIPH_DRIVER; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\libcpu\arm\common; ..\..\..\..\components\finsh; packages\gd32-arm-cmsis-latest\GD32F30x; ..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\components\libc\posix\io\poll; ..\..\..\..\components\drivers\phy; packages\at24cxx-latest; ..\..\..\..\components\libc\posix\ipc; .; ..\..\..\..\components\drivers\spi; board; ..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\libcpu\arm\cortex-m4; applications; ..\libraries\gd32_drivers; ..\..\..\..\components\libc\compilers\common\extension; packages\gd32-arm-cmsis-latest\GD32F30x\GD\GD32F30x\Include; packages\gd32-arm-series-latest\GD32F30x\GD32F30x_standard_peripheral\Include; ..\..\..\..\components\libc\posix\io\epoll; ..\..\..\..\components\drivers\include; ..\..\..\..\components\drivers\smp_call; ..\..\..\..\components\libc\posix\io\eventfd; ..\..\..\..\include; ..\..\..\..\components\net\utest
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../rtthread.bin
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board/linker_scripts/link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group at24cxx
    packages/at24cxx-latest/: at24cxx.c
  group CPU
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
    ../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
  group Drivers
    board/: board.c board_msd_init.c
    packages/gd32-arm-series-latest/GD32F30x/GD32F30x_standard_peripheral/Source/: gd32f30x_dma.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_hard_i2c.c drv_spi.c drv_usart.c
  group Finsh
    ../../../../components/finsh/: msh.c cmd.c shell.c msh_parse.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
    ../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/gd32-arm-cmsis-latest/GD32F30x/GD/GD32F30x/Source/IAR/: startup_gd32f30x_cl.s
    packages/gd32-arm-cmsis-latest/GD32F30x/GD/GD32F30x/Source/: system_gd32f30x.c
    packages/gd32-arm-series-latest/GD32F30x/GD32F30x_standard_peripheral/Source/: gd32f30x_exti.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_rcu.c gd32f30x_spi.c gd32f30x_usart.c
