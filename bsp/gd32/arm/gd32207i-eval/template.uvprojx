# Keil uVision project template.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: GD32F207IK GigaDevice
  pack: GigaDevice.GD32F20x_DFP.2.2.2
  cpu: IRAM(0x20000000,0x040000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3
  c define: GD32F20X_CL USE_STDPERIPH_DRIVER
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\board\linker_scripts\link.sct
