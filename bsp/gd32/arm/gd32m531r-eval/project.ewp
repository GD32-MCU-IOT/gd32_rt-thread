# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32M531xC GD GD32M531xC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: GD32M53X; USE_STDPERIPH_DRIVER; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: ..\libraries\gd32_drivers; .; ..\..\..\..\components\net\utest; packages\gd32-arm-cmsis-latest\GD32M53x; packages\gd32-arm-cmsis-latest\GD32M53x\GD\GD32M53x\Include; ..\..\..\..\components\libc\posix\ipc; ..\..\..\..\include; ..\..\..\..\libcpu\arm\common; ..\..\..\..\components\dfs\dfs_v1\filesystems\devfs; ..\..\..\..\components\libc\posix\io\eventfd; ..\..\..\..\components\drivers\spi; board; ..\..\..\..\components\libc\posix\io\epoll; ..\..\..\..\components\dfs\dfs_v1\include; ..\..\..\..\components\drivers\spi\sfud\inc; ..\..\..\..\libcpu\arm\cortex-m33; packages\gd32-arm-series-latest\GD32M53x\GD32M53x_standard_peripheral\Include; ..\..\..\..\components\libc\posix\io\poll; applications; ..\..\..\..\components\libc\compilers\common\extension; ..\..\..\..\components\finsh; packages\at24cxx-latest; ..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\components\drivers\smp_call; ..\..\..\..\components\drivers\phy; ..\..\..\..\components\drivers\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board/linker_scripts/link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; GD32M53X; USE_STDPERIPH_DRIVER; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group at24cxx
    packages/at24cxx-latest/: at24cxx.c
  group CPU
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m33/: context_iar.S cpuport.c syscall_iar.S trustzone.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
    ../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c dev_spi_flash_sfud.c
    ../../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
  group Drivers
    board/: board.c board_msd_init.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_hard_i2c.c drv_spi.c drv_spi_flash.c drv_usart.c
  group Filesystem
    ../../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../components/finsh/: cmd.c shell.c msh_file.c msh.c msh_parse.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
    ../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/gd32-arm-cmsis-latest/GD32M53x/GD/GD32M53x/Source/IAR/: startup_gd32m53x.s
    packages/gd32-arm-cmsis-latest/GD32M53x/GD/GD32M53x/Source/: system_gd32m53x.c
    packages/gd32-arm-series-latest/GD32M53x/GD32M53x_standard_peripheral/Source/: gd32m53x_adc.c gd32m53x_can.c gd32m53x_cfmu.c gd32m53x_cmp.c gd32m53x_cptimer.c gd32m53x_cptimerw.c gd32m53x_crc.c gd32m53x_dac.c gd32m53x_dbg.c gd32m53x_dma.c gd32m53x_evic.c gd32m53x_exti.c gd32m53x_fmc.c gd32m53x_fwdgt.c gd32m53x_gpio.c gd32m53x_gptimer.c gd32m53x_gtoc.c gd32m53x_i2c.c gd32m53x_misc.c gd32m53x_pmu.c gd32m53x_poc.c gd32m53x_rcu.c gd32m53x_spi.c gd32m53x_svpwm.c gd32m53x_syscfg.c gd32m53x_timer.c gd32m53x_tmu.c gd32m53x_uart.c gd32m53x_wwdgt.c
