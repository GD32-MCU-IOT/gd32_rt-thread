# Keil uVision project project.uvprojx, settings and files
target rt-thread (6160000::V6.16::ARMCLANG)
  device: GD32E113VB GigaDevice
  pack: GigaDevice.GD32E11x_DFP.1.4.0
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E113, RT_USING_LIBC, USE_STDPERIPH_DRIVER, __RTTHREAD__, RT_USING_ARMLIBC, __CLK_TCK=RT_TICK_PER_SECOND, GD32E11X, __STDC_LIMIT_MACROS
  c include: board;..\..\..\..\components\drivers\include;..\..\..\..\include;..\..\..\..\components\libc\posix\io\poll;..\..\..\..\libcpu\arm\cortex-m4;..\..\..\..\components\drivers\phy;..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\compilers\common\include;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;packages\at24cxx-latest;.;..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\libraries\gd32_drivers;..\..\..\..\components\net\utest;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\posix\io\eventfd;packages\gd32-arm-cmsis-latest\GD32E11x\GD\GD32E11x\Include;applications;..\..\..\..\components\drivers\smp_call;packages\gd32-arm-series-latest\GD32E11x\GD32E11x_standard_peripheral\Include;..\..\..\..\components\drivers\spi;..\..\..\..\components\finsh;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\components\libc\posix\ipc;..\..\..\..\libcpu\arm\common
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group at24cxx
    packages/at24cxx-latest/: at24cxx.c
  group CPU
    ../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
    ../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
  group Drivers
    board/: board.c board_msd_init.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_hard_i2c.c drv_spi.c drv_usart.c
  group Finsh
    ../../../../components/finsh/: cmd.c msh.c shell.c msh_parse.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/gd32-arm-cmsis-latest/GD32E11x/GD/GD32E11x/Source/ARM/: startup_gd32e11x.s
    packages/gd32-arm-cmsis-latest/GD32E11x/GD/GD32E11x/Source/: system_gd32e11x.c
    packages/gd32-arm-series-latest/GD32E11x/GD32E11x_standard_peripheral/Source/: gd32e11x_exti.c gd32e11x_gpio.c gd32e11x_i2c.c gd32e11x_misc.c gd32e11x_pmu.c gd32e11x_rcu.c gd32e11x_spi.c gd32e11x_usart.c
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev
