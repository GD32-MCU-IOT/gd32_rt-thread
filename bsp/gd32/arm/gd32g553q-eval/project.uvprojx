# Keil uVision project project.uvprojx, settings and files
target rt-thread (6160000::V6.16::ARMCLANG)
  device: GD32G553QE GigaDevice
  pack: GigaDevice.GD32G5x3_DFP.1.3.0
  cpu: IRAM(0x20000000,0x18000) IRAM2(0x10000000,0x8000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: RT_USING_LIBC, __RTTHREAD__, __STDC_LIMIT_MACROS, GD32G5X3, RT_USING_ARMLIBC, USE_STDPERIPH_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND
  c include: ..\..\..\..\components\drivers\include;..\..\..\..\components\libc\posix\ipc;board;applications;..\..\..\..\libcpu\arm\common;..\..\..\..\include;board;..\..\..\..\components\dfs\dfs_v1\include;..\..\..\..\components\drivers\include;..\..\..\..\libcpu\arm\cortex-m33;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\components\libc\compilers\common\include;..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\components\finsh;packages\gd32-arm-cmsis-latest\GD32G5x3\GD\GD32G5x3\Include;..\..\..\..\components\drivers\phy;packages\at24cxx-latest;..\..\..\..\components\libc\posix\io\eventfd;.;..\..\..\..\components\libc\posix\io\epoll;packages\gd32-arm-series-latest\GD32G5x3\GD32G5x3_standard_peripheral\Include;..\..\..\..\components\net\utest;..\..\..\..\components\drivers\smp_call;..\libraries\gd32_drivers;..\..\..\..\components\libc\posix\io\poll;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\spi
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group at24cxx
    packages/at24cxx-latest/: at24cxx.c
  group CPU
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
    ../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
  group Drivers
    board/: board.c board_msd_init.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_hard_i2c.c drv_spi.c drv_usart.c
  group Filesystem
    ../../../../components/dfs/dfs_v1/src/: dfs_fs.c dfs_posix.c dfs_file.c dfs.c
  group Finsh
    ../../../../components/finsh/: msh.c msh_file.c shell.c cmd.c msh_parse.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsscanf.c
  group Libraries
    packages/gd32-arm-cmsis-latest/GD32G5x3/GD/GD32G5x3/Source/ARM/: startup_gd32g5x3.s
    packages/gd32-arm-cmsis-latest/GD32G5x3/GD/GD32G5x3/Source/: system_gd32g5x3.c
    packages/gd32-arm-series-latest/GD32G5x3/GD32G5x3_standard_peripheral/Source/: gd32g5x3_dma.c gd32g5x3_exti.c gd32g5x3_gpio.c gd32g5x3_i2c.c gd32g5x3_misc.c gd32g5x3_rcu.c gd32g5x3_spi.c gd32g5x3_syscfg.c gd32g5x3_usart.c
software components: CMSIS:CORE 5.5.0
