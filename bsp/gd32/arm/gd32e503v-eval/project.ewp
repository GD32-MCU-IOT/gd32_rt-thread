# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32E503xE GD GD32E503xE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: GD32E50X; GD32E50X_HD; USE_STDPERIPH_DRIVER; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: ..\..\..\..\include; packages\gd32-arm-cmsis-latest\GD32E50x; ..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\components\libc\posix\ipc; ..\..\..\..\components\net\utest; .; ..\..\..\..\components\libc\posix\io\epoll; ..\..\..\..\libcpu\arm\cortex-m33; ..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\components\drivers\spi; packages\gd32-arm-series-latest\GD32E50x\GD32E50x_standard_peripheral\Include; applications; ..\..\..\..\components\drivers\spi\sfud\inc; ..\..\..\..\components\drivers\phy; ..\..\..\..\components\finsh; ..\libraries\gd32_drivers; ..\..\..\..\components\drivers\include; ..\..\..\..\components\libc\posix\io\poll; packages\at24cxx-latest; ..\..\..\..\components\libc\posix\io\eventfd; packages\gd32-arm-cmsis-latest\GD32E50x\GD\GD32E50x\Include; board; ..\..\..\..\components\drivers\smp_call; ..\..\..\..\components\libc\compilers\common\extension; ..\..\..\..\libcpu\arm\common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board/linker_scripts/link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; GD32E50X; GD32E50X_HD; USE_STDPERIPH_DRIVER; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group at24cxx
    packages/at24cxx-latest/: at24cxx.c
  group CPU
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m33/: context_iar.S cpuport.c syscall_iar.S trustzone.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
    ../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c dev_spi_flash_sfud.c
    ../../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
  group Drivers
    board/: board.c board_msd_init.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_hard_i2c.c drv_spi.c drv_spi_flash.c drv_usart.c
  group Finsh
    ../../../../components/finsh/: msh_parse.c cmd.c msh.c shell.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
    ../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/gd32-arm-cmsis-latest/GD32E50x/GD/GD32E50x/Source/IAR/: startup_gd32e50x_hd.s
    packages/gd32-arm-cmsis-latest/GD32E50x/GD/GD32E50x/Source/: system_gd32e50x.c
    packages/gd32-arm-series-latest/GD32E50x/GD32E50x_standard_peripheral/Source/: gd32e50x_dma.c gd32e50x_exti.c gd32e50x_gpio.c gd32e50x_i2c.c gd32e50x_misc.c gd32e50x_rcu.c gd32e50x_spi.c gd32e50x_usart.c
