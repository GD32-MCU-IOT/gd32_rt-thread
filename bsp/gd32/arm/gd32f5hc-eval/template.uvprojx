# Keil uVision project template.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: GD32F5HCRI GigaDevice
  pack: GigaDevice.GD32W51x_F5HC_DFP.2.0.0
  cpu: IRAM(0x20000000,0x50000) IRAM2(0x30000000,0x50000) IROM(0x08000000,0x0200000) IROM2(0x0C000000,0x0200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x30000000 size 0x50000
  scatter file: .\board\linker_scripts\link.sct
software components: CMSIS:CORE 5.5.0
