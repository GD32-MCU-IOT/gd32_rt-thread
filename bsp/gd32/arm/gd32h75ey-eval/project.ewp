# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: GD32H75ExM GD GD32H75ExM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: GD32H75E; USE_STDPERIPH_DRIVER; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\components\libc\compilers\common\include; applications; ..\..\..\..\components\dfs\dfs_v1\filesystems\devfs; ..\..\..\..\libcpu\arm\common; ..\..\..\..\components\libc\posix\ipc; ..\..\..\..\libcpu\arm\cortex-m7; packages\gd32-arm-cmsis-latest\GD32H75E\GD\GD32H75E\Include; ..\..\..\..\components\libc\compilers\common\extension; ..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\components\drivers\spi; ..\..\..\..\components\libc\posix\io\eventfd; ..\..\..\..\components\libc\posix\io\poll; packages\gd32-arm-series-latest\GD32H75E\GD32H75E_standard_peripheral\Include; ..\..\..\..\components\drivers\smp_call; ..\..\..\..\components\finsh; ..\..\..\..\components\drivers\phy; .; board; packages\at24cxx-latest; ..\..\..\..\components\net\utest; ..\libraries\gd32_drivers; ..\..\..\..\components\libc\posix\io\epoll; ..\..\..\..\components\drivers\include; ..\..\..\..\components\dfs\dfs_v1\include; ..\..\..\..\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: board/linker_scripts/link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group at24cxx
    packages/at24cxx-latest/: at24cxx.c
  group CPU
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m7/: context_iar.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
    ../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
  group Drivers
    board/: board.c board_msd_init.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_hard_i2c.c drv_spi.c drv_usart.c
  group Filesystem
    ../../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../components/finsh/: msh_file.c shell.c msh.c msh_file.c msh_file.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
    ../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/gd32-arm-cmsis-latest/GD32H75E/GD/GD32H75E/Source/IAR/: startup_gd32h75e.s
    packages/gd32-arm-cmsis-latest/GD32H75E/GD/GD32H75E/Source/: system_gd32h75e.c
    packages/gd32-arm-series-latest/GD32H75E/GD32H75E_standard_peripheral/Source/: gd32h75e_dma.c gd32h75e_exti.c gd32h75e_gpio.c gd32h75e_i2c.c gd32h75e_misc.c gd32h75e_pmu.c gd32h75e_rcu.c gd32h75e_spi.c gd32h75e_syscfg.c gd32h75e_usart.c
