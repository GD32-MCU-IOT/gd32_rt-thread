# Keil uVision project project.uvprojx, settings and files
target rt-thread (6160000::V6.16::ARMCLANG)
  device: GD32E503VE GigaDevice
  pack: GigaDevice.GD32E50x_DFP.1.9.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1
  c define: __CLK_TCK=RT_TICK_PER_SECOND, USE_STDPERIPH_DRIVER, GD32E50X_HD, __STDC_LIMIT_MACROS, RT_USING_LIBC, RT_USING_ARMLIBC, __RTTHREAD__, GD32E50X
  c include: ..\..\..\..\components\drivers\spi;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\posix\ipc;packages\gd32-arm-cmsis-latest\GD32E50x\GD\GD32E50x\Include;..\libraries\gd32_drivers;board;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\components\drivers\phy;..\..\..\..\components\finsh;..\..\..\..\libcpu\arm\common;..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\libcpu\arm\cortex-m33;..\..\..\..\components\drivers\spi\sfud\inc;packages\gd32-arm-series-latest\GD32E50x\GD32E50x_standard_peripheral\Include;packages\gd32-arm-cmsis-latest\GD32E50x;..\..\..\..\components\net\utest;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;.;packages\at24cxx-latest;..\..\..\..\components\libc\compilers\common\include;..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\components\libc\posix\io\poll;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\smp_call;..\..\..\..\components\libc\posix\io\epoll;applications;..\..\..\..\components\drivers\include;..\..\..\..\include;..\..\..\..\components\drivers\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group at24cxx
    packages/at24cxx-latest/: at24cxx.c
  group CPU
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
    ../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c dev_spi_flash_sfud.c
    ../../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
  group Drivers
    board/: board.c board_msd_init.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_hard_i2c.c drv_spi.c drv_spi_flash.c drv_usart.c
  group Finsh
    ../../../../components/finsh/: msh.c msh_parse.c shell.c cmd.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/gd32-arm-cmsis-latest/GD32E50x/GD/GD32E50x/Source/ARM/: startup_gd32e50x_hd.s
    packages/gd32-arm-cmsis-latest/GD32E50x/GD/GD32E50x/Source/: system_gd32e50x.c
    packages/gd32-arm-series-latest/GD32E50x/GD32E50x_standard_peripheral/Source/: gd32e50x_dma.c gd32e50x_exti.c gd32e50x_gpio.c gd32e50x_i2c.c gd32e50x_misc.c gd32e50x_rcu.c gd32e50x_spi.c gd32e50x_usart.c
software components: CMSIS:CORE 5.6.0
