# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F5HCxI GD GD32F5HCxI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: GD32W51x_F5HC; GD32F5HC; USE_STDPERIPH_DRIVER; SYS_NS; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: ..\libraries\gd32_drivers; ..\..\..\..\components\finsh; ..\..\..\..\components\libc\compilers\common\extension; ..\..\..\..\components\libc\posix\io\eventfd; packages\at24cxx-latest; ..\..\..\..\components\dfs\dfs_v1\include; ..\..\..\..\components\dfs\dfs_v1\filesystems\devfs; ..\..\..\..\components\drivers\include; packages\gd32-arm-cmsis-latest\GD32W51x_F5HC; packages\gd32-arm-series-latest\GD32W51x_F5HC\GD32W51x_F5HC_standard_peripheral\Include; ..\..\..\..\components\drivers\smp_call; ..\..\..\..\libcpu\arm\common; ..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; board; ..\..\..\..\components\libc\posix\ipc; packages\gd32-arm-cmsis-latest\GD32W51x_F5HC\GD\GD32W51x_F5HC\Include; ..\..\..\..\include; applications; ..\..\..\..\libcpu\arm\cortex-m33; ..\..\..\..\components\libc\posix\io\poll; ..\..\..\..\components\libc\posix\io\epoll; ..\..\..\..\components\drivers\spi; ..\..\..\..\components\net\utest; .; ..\..\..\..\components\drivers\phy
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; GD32W51x_F5HC; GD32F5HC; USE_STDPERIPH_DRIVER; SYS_NS; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group at24cxx
    packages/at24cxx-latest/: at24cxx.c
  group CPU
    ../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../libcpu/arm/cortex-m33/: context_iar.S cpuport.c syscall_iar.S trustzone.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
    ../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
  group Drivers
    board/: board.c board_msd_init.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_hard_i2c.c drv_spi.c drv_usart.c
  group Filesystem
    ../../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../components/finsh/: shell.c msh_parse.c msh_file.c cmd.c msh.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
    ../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/gd32-arm-cmsis-latest/GD32W51x_F5HC/GD/GD32W51x_F5HC/Source/IAR/: startup_gd32f5hc.s
    packages/gd32-arm-cmsis-latest/GD32W51x_F5HC/GD/GD32W51x_F5HC/Source/: system_gd32w51x_f5hc.c
    packages/gd32-arm-series-latest/GD32W51x_F5HC/GD32W51x_F5HC_standard_peripheral/Source/: gd32w51x_f5hc_dbg.c gd32w51x_f5hc_dma.c gd32w51x_f5hc_exti.c gd32w51x_f5hc_fmc.c gd32w51x_f5hc_gpio.c gd32w51x_f5hc_i2c.c gd32w51x_f5hc_misc.c gd32w51x_f5hc_rcu.c gd32w51x_f5hc_spi.c gd32w51x_f5hc_syscfg.c gd32w51x_f5hc_usart.c
