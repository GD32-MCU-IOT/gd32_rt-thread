# Keil uVision project template.uvprojx, settings and files
target rt-thread (6160000::V6.16::ARMCLANG)
  device: GD32F503VG GigaDevice
  pack: GigaDevice.GD32F50x_DFP.0.0.4
  cpu: IRAM(0x20000000,0x030000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(120000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: GD32F50X, GD32F503
  c misc: -fno-strict-aliasing
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  scatter file: .\board\linker_scripts\link.sct
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev
