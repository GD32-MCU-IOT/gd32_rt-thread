# Keil uVision project project.uvprojx, settings and files
target rt-thread (6160000::V6.16::ARMCLANG)
  device: GD32C113VB GigaDevice
  pack: GigaDevice.GD32C11x_DFP.1.3.0
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __RTTHREAD__, USE_STDPERIPH_DRIVER, RT_USING_LIBC, GD32C113, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, GD32C11X
  c include: ..\..\..\..\components\libc\posix\io\poll;..\..\..\..\components\libc\compilers\common\extension;applications;..\libraries\gd32_drivers;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;packages\gd32-arm-series-latest\GD32C11x\GD32C11x_standard_peripheral\Include;..\..\..\..\components\drivers\include;..\..\..\..\libcpu\arm\common;..\..\..\..\components\drivers\include;..\..\..\..\include;..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\components\drivers\include;board;..\..\..\..\libcpu\arm\cortex-m4;..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\components\drivers\spi;..\..\..\..\components\libc\posix\ipc;..\..\..\..\components\drivers\phy;..\..\..\..\components\finsh;..\..\..\..\components\drivers\smp_call;packages\gd32-arm-cmsis-latest\GD32C11x\GD\GD32C11x\Include;..\..\..\..\components\libc\posix\io\eventfd;.;packages\at24cxx-latest;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\compilers\common\include;..\..\..\..\components\drivers\include;..\..\..\..\components\net\utest
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group at24cxx
    packages/at24cxx-latest/: at24cxx.c
  group CPU
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
    ../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
  group Drivers
    board/: board.c board_msd_init.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_hard_i2c.c drv_spi.c drv_usart.c
  group Finsh
    ../../../../components/finsh/: shell.c msh.c cmd.c msh_parse.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/gd32-arm-cmsis-latest/GD32C11x/GD/GD32C11x/Source/ARM/: startup_gd32c11x.s
    packages/gd32-arm-cmsis-latest/GD32C11x/GD/GD32C11x/Source/: system_gd32c11x.c
    packages/gd32-arm-series-latest/GD32C11x/GD32C11x_standard_peripheral/Source/: gd32c11x_exti.c gd32c11x_gpio.c gd32c11x_i2c.c gd32c11x_misc.c gd32c11x_pmu.c gd32c11x_rcu.c gd32c11x_spi.c gd32c11x_usart.c
software components: CMSIS:CORE 5.5.0
