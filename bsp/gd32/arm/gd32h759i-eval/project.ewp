# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32H759xM GD GD32H759xM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: GD32H7XX; USE_STDPERIPH_DRIVER; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: ..\..\..\..\components\libc\posix\ipc; ..\..\..\..\components\drivers\spi; ..\..\..\..\components\libc\posix\io\eventfd; board; ..\..\..\..\components\dfs\dfs_v1\include; ..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\components\drivers\include; ..\libraries\gd32_drivers; ..\..\..\..\components\libc\posix\io\epoll; ..\..\..\..\libcpu\arm\common; ..\..\..\..\components\finsh; packages\at24cxx-latest; ..\..\..\..\components\libc\posix\io\poll; packages\gd32-arm-cmsis-latest\GD32H7xx\GD\GD32H7xx\Include; applications; ..\..\..\..\components\libc\compilers\common\extension; ..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; .; packages\gd32-arm-cmsis-latest\GD32H7xx; ..\..\..\..\components\drivers\phy; ..\..\..\..\components\dfs\dfs_v1\filesystems\devfs; ..\..\..\..\libcpu\arm\cortex-m7; ..\..\..\..\components\net\utest; ..\..\..\..\components\drivers\smp_call; packages\gd32-arm-series-latest\GD32H7xx\GD32H7xx_standard_peripheral\Include; ..\..\..\..\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: board/linker_scripts/link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; GD32H7XX; USE_STDPERIPH_DRIVER; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group at24cxx
    packages/at24cxx-latest/: at24cxx.c
  group CPU
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m7/: context_iar.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/misc/: rt_drv_pwm.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
    ../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
  group Drivers
    board/: board.c board_msd_init.c
    packages/gd32-arm-series-latest/GD32H7xx/GD32H7xx_standard_peripheral/Source/: gd32h7xx_timer.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_hard_i2c.c drv_pwm.c drv_spi.c drv_usart.c
  group Filesystem
    ../../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../components/finsh/: msh_file.c cmd.c msh.c msh_parse.c shell.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
    ../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/gd32-arm-cmsis-latest/GD32H7xx/GD/GD32H7xx/Source/IAR/: startup_gd32h7xx.s
    packages/gd32-arm-cmsis-latest/GD32H7xx/GD/GD32H7xx/Source/: system_gd32h7xx.c
    packages/gd32-arm-series-latest/GD32H7xx/GD32H7xx_standard_peripheral/Source/: gd32h7xx_dma.c gd32h7xx_exti.c gd32h7xx_gpio.c gd32h7xx_i2c.c gd32h7xx_misc.c gd32h7xx_pmu.c gd32h7xx_rcu.c gd32h7xx_spi.c gd32h7xx_syscfg.c gd32h7xx_usart.c
