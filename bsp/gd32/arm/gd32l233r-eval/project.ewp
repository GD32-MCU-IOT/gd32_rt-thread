# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32L233xC GD GD32L233xC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: GD32L233; USE_STDPERIPH_DRIVER; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: ..\..\..\..\components\libc\compilers\common\extension; ..\..\..\..\components\dfs\dfs_v1\include; .; ..\..\..\..\components\dfs\dfs_v1\filesystems\devfs; ..\..\..\..\components\drivers\phy; ..\..\..\..\components\net\utest; ..\..\..\..\libcpu\arm\cortex-m23; ..\libraries\gd32_drivers; applications; ..\..\..\..\components\drivers\spi; ..\..\..\..\include; packages\gd32-arm-cmsis-latest\GD\GD32L23x\Include; ..\..\..\..\components\drivers\spi\sfud\inc; ..\..\..\..\components\libc\posix\io\eventfd; ..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\components\libc\posix\ipc; packages\gd32-arm-series-latest\Include; ..\..\..\..\components\drivers\smp_call; ..\..\..\..\components\drivers\include; ..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\components\finsh; ..\..\..\..\components\libc\posix\io\epoll; packages\at24cxx-latest; ..\..\..\..\components\libc\posix\io\poll; ..\..\..\..\libcpu\arm\common; board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; GD32L233; USE_STDPERIPH_DRIVER; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group at24cxx
    packages/at24cxx-latest/: at24cxx.c
  group CPU
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m23/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
    ../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c dev_spi_flash_sfud.c
    ../../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
  group Drivers
    board/: board.c board_msd_init.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_hard_i2c.c drv_spi.c drv_spi_flash.c drv_usart.c
  group Filesystem
    ../../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../components/finsh/: msh.c cmd.c msh_file.c shell.c msh_parse.c
  group GD32L23x_StdPeriph
    packages/gd32-arm-series-latest/Source/: gd32l23x_vref.c gd32l23x_trng.c gd32l23x_syscfg.c gd32l23x_slcd.c gd32l23x_misc.c gd32l23x_ctc.c gd32l23x_pmu.c gd32l23x_adc.c gd32l23x_dac.c gd32l23x_rtc.c gd32l23x_cmp.c gd32l23x_timer.c gd32l23x_lpuart.c gd32l23x_rcu.c gd32l23x_fwdgt.c gd32l23x_crc.c gd32l23x_wwdgt.c gd32l23x_exti.c gd32l23x_dbg.c gd32l23x_dma.c gd32l23x_gpio.c gd32l23x_i2c.c gd32l23x_fmc.c gd32l23x_spi.c gd32l23x_usart.c gd32l23x_lptimer.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
    ../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/gd32-arm-cmsis-latest/GD/GD32L23x/Source/: system_gd32l23x.c
    packages/gd32-arm-cmsis-latest/GD/GD32L23x/Source/IAR/: startup_gd32l233.s
