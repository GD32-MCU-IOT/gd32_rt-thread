# Keil uVision project project.uvproj, settings and files
target rt-thread (ARM-ADS)
  device: GD32F305RC GigaDevice
  cpu: IRAM(0x20000000-0x20018000) IROM(0x08000000-0x08040000) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: rtthread +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_ARMLIBC, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, USE_STDPERIPH_DRIVER, GD32F30X_HD, RT_USING_LIBC
  c include: ..\..\..\..\libcpu\arm\common;..\..\..\..\components\drivers\include;applications;..\..\..\..\components\drivers\include;..\..\..\..\include;packages\gd32-arm-cmsis-latest\GD32F30x;..\..\..\..\components\finsh;..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\components\libc\posix\ipc;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;packages\gd32-arm-cmsis-latest\GD32F30x\GD\GD32F30x\Include;..\..\..\..\libcpu\arm\cortex-m4;..\..\..\..\components\drivers\phy;..\..\..\..\components\libc\posix\io\epoll;board;..\..\..\..\components\drivers\include;.;..\..\..\..\components\drivers\smp_call;..\libraries\gd32_drivers;packages\gd32-arm-series-latest\GD32F30x\GD32F30x_standard_peripheral\Include;..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\components\libc\compilers\common\include;..\..\..\..\components\libc\posix\io\poll;..\..\..\..\components\drivers\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Applications
    applications/: main.c
  group Compiler
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_usart.c
  group Finsh
    ../../../../components/finsh/: msh_parse.c msh.c cmd.c shell.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../src/klibc/: rt_vsnprintf_tiny.c rt_vsscanf.c kstdio.c kstring.c kerrno.c
  group libcpu
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    packages/gd32-arm-cmsis-latest/GD32F30x/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
    packages/gd32-arm-cmsis-latest/GD32F30x/GD/GD32F30x/Source/: system_gd32f30x.c
    packages/gd32-arm-series-latest/GD32F30x/GD32F30x_standard_peripheral/Source/: gd32f30x_exti.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_rcu.c gd32f30x_usart.c
