# Keil uVision project project.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32H759IM GigaDevice
  pack: GigaDevice.GD32H7xx_DFP.1.4.0
  cpu: IRAM(0x24000000,0x000D0000) IRAM2(0x00000000,0x00010000) IROM(0x08000000,0x03C0000) XRAM(0x20000000,0x00020000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RT_USING_LIBC, USE_STDPERIPH_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARMLIBC, __RTTHREAD__, GD32H7XX, __STDC_LIMIT_MACROS
  c include: ..\..\..\..\components\libc\compilers\common\include;packages\gd32-arm-cmsis-latest\GD32H7xx;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\smp_call;..\..\..\..\components\libc\posix\io\poll;..\..\..\..\libcpu\arm\cortex-m7;..\libraries\gd32_drivers;..\..\..\..\components\dfs\dfs_v1\include;..\..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\..\components\drivers\phy;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\compilers\common\extension;packages\at24cxx-latest;board;..\..\..\..\components\drivers\spi;..\..\..\..\include;..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\components\libc\posix\io\eventfd;packages\gd32-arm-cmsis-latest\GD32H7xx\GD\GD32H7xx\Include;packages\gd32-arm-series-latest\GD32H7xx\GD32H7xx_standard_peripheral\Include;..\..\..\..\libcpu\arm\common;..\..\..\..\components\net\utest;.;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\posix\ipc;..\..\..\..\components\finsh;applications;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include
  memory RVCT4: ROM 0x8000000 size 0x3c0000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xd0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group at24cxx
    packages/at24cxx-latest/: at24cxx.c
  group CPU
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/misc/: rt_drv_pwm.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
    ../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
  group Drivers
    board/: board.c board_msd_init.c
    packages/gd32-arm-series-latest/GD32H7xx/GD32H7xx_standard_peripheral/Source/: gd32h7xx_timer.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_hard_i2c.c drv_pwm.c drv_spi.c drv_usart.c
  group Filesystem
    ../../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../components/finsh/: cmd.c msh_file.c msh.c shell.c msh_parse.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/gd32-arm-cmsis-latest/GD32H7xx/GD/GD32H7xx/Source/ARM/: startup_gd32h7xx.s
    packages/gd32-arm-cmsis-latest/GD32H7xx/GD/GD32H7xx/Source/: system_gd32h7xx.c
    packages/gd32-arm-series-latest/GD32H7xx/GD32H7xx_standard_peripheral/Source/: gd32h7xx_dma.c gd32h7xx_exti.c gd32h7xx_gpio.c gd32h7xx_i2c.c gd32h7xx_misc.c gd32h7xx_pmu.c gd32h7xx_rcu.c gd32h7xx_spi.c gd32h7xx_syscfg.c gd32h7xx_usart.c
