# Keil uVision project template.uvprojx, settings and files
target rt-thread (6160000::V6.16::ARMCLANG)
  device: GD32M531RC GigaDevice
  pack: GigaDevice.GD32M53x_DFP.0.3.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x040000) IROM2(0x08800000,0x010000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: GD32M53X
  c misc: -fno-strict-aliasing
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT5: ROM 0x8800000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev
