# Keil uVision project template.uvprojx, settings and files
target rtthread (6160000::V6.16::ARMCLANG)
  device: GD32E235CB GigaDevice
  pack: GigaDevice.GD32E23x_DFP.2.3.2
  cpu: IRAM(0x20000000,0x0004000) IROM(0x08000000,0x0020000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\board\linker_scripts\link.sct
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev
